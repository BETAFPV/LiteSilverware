# Keil uVision project LiteSilverware.uvprojx, settings and files
target LiteSilverware (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F042G6Ux STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00001800) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: LiteSilverware
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F042
  c include: ..\lib\CMSIS\Include;..\lib\CMSIS\Device\ST\STM32F0xx\Include;..\lib\STM32F0xx_StdPeriph_Driver\inc;..\lib;..\src\rx;..\src\flight;..\src\driver;..\src\config;..\src\math;..\src\battery;..\src\osd
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1800
  group user
    ../src/: main.c
  group rx
    ../src/rx/: rx_bayang.c xn297.c
  group driver
    ../src/driver/: time.c system.c misc_gpio.c bus_softspi.c serial_uart.c bus_i2c.c pwm.c mpu6050.c adc.c led.c flash.c drv_fmc1.c
  group flight
    ../src/flight/: imu.c angle_pid.c control.c pid.c stickvector.c
  group startup
    ../lib/: system_stm32f0xx.c
    ../lib/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f042.s
  group lib
    ../lib/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group config
    ../src/config/: config.h defines.h hardware.h
  group math
    ../src/math/: util.c filter.cpp
  group battery
    ../src/battery/: battery.c
  group osd
    ../src/osd/: osd.c item.c
